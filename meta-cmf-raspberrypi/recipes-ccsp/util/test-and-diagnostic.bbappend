require recipes-ccsp/ccsp/ccsp_common_rpi.inc
