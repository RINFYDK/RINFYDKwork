EXTRA_OECONF=" --enable-ert"
EXTRA_OECONF+=" --enable-platform"
