SRC_URI_remove = " \
    file://rdk_enhancement.patch \
    file://double_free.patch \
    file://snmp-crash.patch \
    file://rdkb_snmp.patch \
"
