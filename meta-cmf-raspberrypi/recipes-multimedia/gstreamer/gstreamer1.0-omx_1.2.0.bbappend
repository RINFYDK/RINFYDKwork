SRC_URI_remove_krogoth = "file://0007-omxvideodec-Use-gstglmemoryegl-for-the-RPi.patch"
