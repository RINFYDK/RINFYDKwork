EXTRA_OECONF += "--enable-pcre32"
PACKAGECONFIG_append = " pcre32 "
