SYSTEMD_SERVICE_${PN} = ""

FILES_${PN}_append = " /lib/systemd/system/dnsmasq.service"
