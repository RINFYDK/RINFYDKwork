
# Advance SRCREV on the 2.26 branch used in krogoth release to pick up the fix for
# a bug in binutils which resulted runtime errors on php and MariaDB components. 
SRCREV = "544ddf9322b1b83982e5cb84a54d084ee7e718ea"
