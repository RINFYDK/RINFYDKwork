INSANE_SKIP_${PN} += "la"
