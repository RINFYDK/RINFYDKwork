DEPENDS_remove_rpi = " servicemanager"
