
SRC_URI = "${RDK_GENERIC_ROOT_GIT}/mediaframework/devices/intel-x86-pc/rdkri;protocol=${RDK_GIT_PROTOCOL};branch=${RDK_GIT_BRANCH}"
