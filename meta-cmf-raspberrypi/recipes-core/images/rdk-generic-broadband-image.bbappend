IMAGE_FEATURES_remove_rpi = "read-only-rootfs"
