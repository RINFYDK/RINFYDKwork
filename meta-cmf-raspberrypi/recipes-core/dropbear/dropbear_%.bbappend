SRC_URI_remove = " file://verbose.patch"
