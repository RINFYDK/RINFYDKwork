PACKAGECONFIG += "resolved"

#backport patches not needed for systemd 229
BACKPORTS = ""
