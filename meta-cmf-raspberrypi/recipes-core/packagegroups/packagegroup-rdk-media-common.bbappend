RDEPENDS_packagegroup-rdk-media-common_remove_rpi = "\
    closedcaption \
    servicemanager \
    storagemanager \
    iarm-set-powerstate \
    iarm-query-powerstate \
    key-simulator \
"
