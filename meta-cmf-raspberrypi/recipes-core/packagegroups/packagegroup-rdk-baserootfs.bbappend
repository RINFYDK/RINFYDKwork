RDEPENDS_packagegroup-rdk-baserootfs_remove_rpi += "\
    tr69agent \
    tr69hostif \
"
