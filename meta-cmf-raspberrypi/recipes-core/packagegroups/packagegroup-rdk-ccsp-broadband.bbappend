RDEPENDS_packagegroup-rdk-ccsp-broadband_remove = "ccsp-moca"
RDEPENDS_packagegroup-rdk-ccsp-broadband_remove = "ccsp-moca-ccsp"

# Set the gwprov app for RPi
GWPROVAPP = "ccsp-gwprovapp"
