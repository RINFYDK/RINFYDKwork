RDEPENDS_packagegroup-rdk-oss-broadband_append = " \
    iw \
    linux-firmware \
    hostapd \
	crda	\
"

RDEPENDS_packagegroup-rdk-oss-broadband_remove = " \
    alljoyn \
"
