RDEPENDS_packagegroup-rdk-oss-broadband_append = " \
        init-ifupdown \
        initscripts \
"

